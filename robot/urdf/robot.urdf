Commit message: forward and backward teleop problem solved

File: robot/urdf/robot.urdf (robot description, URDF)
Before this commit: robot robot, 3 links, 2 joints
Joints:
- joint left_joint: axis 0 0 1 -> 0 0 -1
- joint right_joint: axis 0 0 1 -> 0 0 -1
